# Repository Hexagram-Lab/LVDS-DP-Driver

File README.md:

# LVDS-DP-Driver
A highly integrated LVDS driving board with DisplayPort (or Type-C)

## Make sure you're running the latest Nightly Build of KiCAD before open this project.

## KiCad design LVDS-DP-Driver.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C9, C14, C16, C17, C23, C27, C31, C32, C33, C34, C36, C38, C39, C42, C43, C44, C56, C61, C64: 100nF; C_0603_1608Metric
C7: 68uF; CP_Radial_D6.3mm_P2.50mm
C8: 10uF * 3; C_2220_5650Metric
C10: 15nF; C_0603_1608Metric
C11: 100pF; C_0603_1608Metric
C12: 6.8nF; C_0603_1608Metric
C13: 82pF; C_0603_1608Metric
C15: 47pF; C_0603_1608Metric
C18, C30, C35, C37: 1uF; C_0603_1608Metric
C19: 22uF * 3; C_0805_2012Metric
C20, C21: 47uF; C_1210_3225Metric
C22, C53, C54, C63: 10uF; C_0603_1608Metric
C24, C59: 39nF; C_0603_1608Metric
C25, C60: 220nF; C_0603_1608Metric
C26, C58: 2.2uF; C_0603_1608Metric
C28: 4.7uF; C_0603_1608Metric
C29: 56pF; C_0603_1608Metric
C40, C45: 10uF; CP_EIA-3528-21_Kemet-B
C52: 4.7nF; C_0603_1608Metric
C55: 3.3nF; C_0603_1608Metric
C57: 33pF; C_0603_1608Metric
C62: 220pF; C_0603_1608Metric
C65: 22uF; C_0603_1608Metric
D1: MBR0580S1-7; D_SOD-123
D2: B5817WS-MS; D_SOD-323
D3: B110WS; D_SOD-323
D4: G; D_0603_1608Metric
D5: O; D_0603_1608Metric
D6, D7: DSK12; D_SOD-123F
J1: 47272-0001; MOLEX_47272-0001
J2: Conn_02x15_Odd_Even; PinHeader_2x15_P2.00mm_Vertical
J3: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J4, J6: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
L1: CYA0650-3.3UH; L_0530
L2, L4: CKST353220-2.2uH/M; CKST353220
L3: CKST322512-1uH/M; CKST322512
Q1, Q2, Q3, Q11: AGM612AP; PDFN8_3x3
Q4, Q5: MMBT3904; SOT-23
Q6, Q8, Q9, Q10: 2N7002; SOT-23
Q7: AO3401A; SOT-23
Q12, Q13, Q14, Q15: AGM308AP; PDFN8_3x3
R1, R2: 1M; R_0603_1608Metric
R3, R22, R23, R25, R27, R36: 1K; R_0603_1608Metric
R4: 100K; R_0603_1608Metric
R5: 249K; R_0603_1608Metric
R6: 42K2; R_0603_1608Metric
R7: 2K; R_0603_1608Metric
R8, R18, R54: 10R; R_0603_1608Metric
R9: 6K19; R_0603_1608Metric
R10: 93K1; R_0603_1608Metric
R11: 13K; R_0603_1608Metric
R12: 15m; R_0805_2012Metric
R13, R14: 100R; R_0603_1608Metric
R16: 280K; R_0603_1608Metric
R17: 20K; R_0603_1608Metric
R19: 12m; R_0603_1608Metric
R20: 1K62; R_0603_1608Metric
R21: 10m; R_0603_1608Metric
R24, R26, R28, R29, R30, R31, R33, R34, R35, R39, R40, R41, R56: 10K; R_0603_1608Metric
R32, R37, R38, R42, R43, R44, R45, R46: 4K7; R_0603_1608Metric
R55: 2K32; R_0603_1608Metric
R57: 187K; R_0603_1608Metric
R58: 150K; R_0603_1608Metric
RN1: R_Pack04; R_Array_Concave_4x0603
TP1: SMBUS_SDA; TestPoint_Pad_1.0x1.0mm
TP2: SMBUS_SCL; TestPoint_Pad_1.0x1.0mm
TP3, TP4: TestPoint; TestPoint_Pad_D4.0mm
U1: CS5211; QFN-68-1EP_8x8mm_P0.4mm_EP5.2x5.2mm
U2: LM5176; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.85x5.4mm
U3: AT24C64; SOIC-8_3.9x4.9mm_P1.27mm
U5, U8: LM25141; VQFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm_ThermalVias
U9: TLV62130; VQFN-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm

Connections:
+1V8: C30.2, C31.2, C32.2, C33.2, C34.2, C35.1, C36.1, C65.1, L4.2, R56.1, R57.1, U1.3 (AVDD), U1.4 (AVDD), U1.7 (DVDD), U1.42 (DVDD), U1.60 (AVDD), U1.66 (AVDD), U1.67 (AVDD), U9.14 (VOS)
+3.3V: C37.1, C38.1, C39.1, C54.1, J4.3, Q6.1 (G), Q10.1 (G), R21.2, R22.1, R27.1, R28.1, R29.1, R30.1, R31.1, R37.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.2, R46.2, U1.18 (LVDD), U1.32 (LVDD), U1.52 (LVDD), U3.8 (VDD), U8.17 (VOUT)
+5V: C28.1, J4.1, J6.1, R19.2, U5.17 (VOUT)
+12V: C19.1, C20.1, C21.1, C22.1, C53.1, C63.1, C64.1, J6.3, Q3.3 (D), Q12.3 (D), Q14.3 (D), R16.1, U2.12 (VOSNS), U5.15 (VIN), U5.23 (EN), U8.15 (VIN), U8.23 (EN), U9.10 (AVIN), U9.11 (PVIN), U9.12 (PVIN), U9.13 (EN)
/A0N: J2.7, U1.31 (LDC0N)
/A0P: J2.8, U1.30 (LDC0P)
/A1N: J2.9, U1.29 (LDC1N)
/A1P: J2.10, U1.28 (LDC1P)
/A2N: J2.11, U1.27 (LDC2N)
/A2P: J2.12, U1.26 (LDC2P)
/A3N: J2.17, U1.23 (LDC3N)
/A3P: J2.18, U1.22 (LDC3P)
/ACLKN: J2.15, U1.25 (LL1CN)
/ACLKP: J2.16, U1.24 (LL1CP)
/AUXN: C5.2, U1.43 (AUXN)
/AUXP: C6.2, U1.44 (AUXP)
/B0N: J2.19, U1.20 (LDC4N)
/B0P: J2.20, U1.19 (LDC4P)
/B1N: J2.21, U1.17 (LDC5N)
/B1P: J2.22, U1.16 (LDC5P)
/B2N: J2.23, U1.15 (LDC6N)
/B2P: J2.24, U1.14 (LDC6P)
/B3N: J2.29, U1.13 (LDC7N)
/B3P: J2.30, U1.12 (LDC7P)
/BCLKN: J2.27, U1.11 (LL2CN)
/BCLKP: J2.28, U1.10 (LL2CP)
/BKUP_BTN: C42.1, J5.1, R39.2, U1.56 (BLUP)
/BLDN: C43.1, J5.2, R40.2, U1.55 (BLDN)
/BUCK3_BIASVCC: C58.1, D7.2 (A), U8.10 (VCC)
/BUCK3_SW: C56.1, L3.1, Q14.2 (S), Q15.3 (D), U8.12 (SW)
/BUCK5_BIASVCC: C26.1, D6.2 (A), U5.10 (VCC)
/BUCK5_SW: C27.1, L2.1, Q12.2 (S), Q13.3 (D), U5.12 (SW)
/CS_3: L3.2, R21.1, U8.18 (CS)
/CS_5: L2.2, R19.1, U5.18 (CS)
/DP0N: C1.2, U1.62 (DP0N)
/DP0P: C2.2, U1.61 (DP0P)
/DP1N: C3.2, U1.65 (DP1N)
/DP1P: C4.2, U1.64 (DP1P)
/DP_IN_HPD: R3.2, U1.59 (HPDET)
/E2_SCL: R46.1, U1.51 (MSCL), U3.6 (SCL)
/E2_SDA: R45.1, U1.50 (MSDA), U3.5 (SDA)
/ENABLE: R5.2, R6.1, U2.1 (EN)
/EN_BKLT: Q6.2 (S), U1.46 (EN_BKLT)
/EN_VCC: R35.1, U1.47 (EN_VCC)
/FB_3: C61.1, U8.1 (DEMB), U8.2 (VDDA), U8.5 (DITH), U8.6 (OSC), U8.19 (FB)
/GLED: R23.1, U1.57 (GLED)
/GPIO0: R31.2, RN1.5 (R4.2), U1.33 (GPIO0)
/GPIO1: R30.2, RN1.6 (R3.2), U1.34 (GPIO1)
/GPIO2: R29.2, RN1.7 (R2.2), U1.37 (GPIO2)
/GPIO3: R28.2, RN1.8 (R1.2), U1.38 (GPIO3)
/HDRV1: Q1.1 (G), U2.27 (HDRV1)
/HDRV2: Q3.1 (G), U2.19 (HDRV2)
/HDRV_3: Q14.1 (G), R54.2, U8.14 (HOL)
/HDRV_5: Q12.1 (G), R18.2, U5.14 (HOL)
/HPD_DET_DP0: J1.18, R3.1, R4.2
/LCD_BKLT_VCC: C45.1, J3.1, J3.2, J6.2
/LDRV1: Q2.1 (G), U2.25 (LDRV1)
/LDRV2: Q11.1 (G), U2.21 (LDRV2)
/LDRV_3: Q15.1 (G), U8.7 (LOL), U8.8 (LO)
/LDRV_5: Q13.1 (G), U5.7 (LOL), U5.8 (LO)
/MAINPWR_FB: R16.2, R17.1, U2.11 (FB)
/OLED: R25.1, U1.58 (OLED)
/PWM0: Q10.2 (S), R37.2, U1.48 (PWMOUT0)
/PWRDN: C44.1, J5.3, R41.2, U1.41 (PWRDN)
/P_BKLT_EN: J3.3, Q6.3 (D), R32.2
/P_PWM: J3.4, Q10.3 (D), R38.2
/RCS: Q2.2 (S), Q11.2 (S), R12.2, R14.1
/RX_AUXN: C5.1, J1.17
/RX_AUXP: C6.1, J1.15
/RX_DP0N: C1.1, J1.10
/RX_DP0P: C2.1, J1.12
/RX_DP1N: C3.1, J1.7
/RX_DP1P: C4.1, J1.9
/SW1: C17.2, L1.1, Q1.2 (S), Q2.3 (D), U2.28 (SW1)
/SW2: C16.1, L1.2, Q3.2 (S), Q11.3 (D), U2.18 (SW2)
/VCC: C18.1, D2.2 (A), D3.2 (A), U2.23 (VCC)
/VINSNS: R7.2, U2.3 (VISNS)
GND: C7.2, C8.2, C9.2, C10.1, C11.1, C13.2, C14.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C28.2, C29.2, C30.1, C31.1, C32.1, C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C42.2, C43.2, C44.2, C45.2, C53.2, C54.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.1, C63.2, C64.2, C65.2, J1.2, J1.5, J1.8, J1.11, J1.16, J1.19, J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J2.4, J2.5, J2.6, J2.13, J2.14, J2.25, J2.26, J3.5, J3.6, J5.4, Q4.2 (E), Q5.2 (E), Q8.2 (S), Q9.2 (S), Q13.2 (S), Q15.2 (S), R1.2, R2.2, R4.1, R6.2, R9.1, R10.1, R11.1, R12.1, R13.1, R17.2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
HT: C40.1, J2.1, J2.2, J2.3, Q7.3 (D), R32.1, R36.1, R38.1
unnamed: C12.1, R9.2
unnamed: C52.2, R20.1
unnamed: C55.2, R55.1
unnamed: D1.1 (K), R8.1
unnamed: C16.2, D2.1 (K), U2.20 (BOOT2)
unnamed: C17.1, D3.1 (K), U2.26 (BOOT1)
unnamed: D4.2 (A), R22.2
unnamed: D4.1 (K), Q4.3 (C)
unnamed: D5.2 (A), R27.2
unnamed: D5.1 (K), Q5.3 (C)
unnamed: C27.2, D6.1 (K), U5.11 (HB)
unnamed: C56.2, D7.1 (K), U8.11 (HB)
unnamed: J1.13, R1.1
unnamed: J1.14, R2.1
unnamed: J4.2, Q7.2 (S), R33.1
unnamed: L4.1, U9.1 (SW), U9.2 (SW), U9.3 (SW)
unnamed: Q4.1 (B), R23.2, R24.2
unnamed: Q5.1 (B), R25.2, R26.2
unnamed: Q7.1 (G), R33.2, R34.1
unnamed: Q8.3 (D), Q9.1 (G), R34.2
unnamed: Q8.1 (G), R35.2
unnamed: Q9.3 (D), R36.2
unnamed: TP2.1, U1.54 (SSCL)
unnamed: TP1.1, U1.53 (SSDA)
unnamed: C14.1, U2.24 (BIAS)
unnamed: C11.2, C12.2, U2.9 (COMP)
unnamed: C15.2, R14.2, U2.16 (CS)
unnamed: C15.1, R13.2, U2.15 (CSG)
unnamed: R10.2, U2.4 (MODE)
unnamed: C13.1, U2.7 (SLOPE)
unnamed: C10.2, U2.8 (SS)
unnamed: R11.2, U2.6 (SYNC)
unnamed: C9.1, R8.2, U2.2 (VIN)
unnamed: R44.2, U3.1 (A0)
unnamed: R43.2, U3.2 (A1)
unnamed: R42.2, U3.3 (A2)
unnamed: C29.1, C52.1, U5.20 (COMP)
unnamed: C23.1, U5.1 (DEMB), U5.2 (VDDA), U5.5 (DITH), U5.6 (OSC)
unnamed: R18.1, U5.13 (HO)
unnamed: C25.1, U5.24 (RES)
unnamed: C24.1, U5.22 (SS)
unnamed: C55.1, C57.1, U8.20 (COMP)
unnamed: R54.1, U8.13 (HO)
unnamed: C60.1, U8.24 (RES)
unnamed: C59.1, U8.22 (SS)
unnamed: R57.2, R58.1, U9.5 (FB)
unnamed: R56.2, U9.4 (PG)
unnamed: C62.2, U9.9 (SS)
VDC: C7.1, C8.1, D1.2 (A), Q1.3 (D), R5.1, R7.1, TP3.1

Notes on the sheet:
FS55X106K101EGG
同焊盘堆叠焊接
SPT1HM680E09ORVZC

Board: 4 copper layers, 50.0 x 50.0 mm, 143 parts (0 on the bottom side), 124 nets.

## Commit log

2022-09-22 KiCAD Project Creation
2022-09-22 Add KiCAD Version Requirement
2022-09-22 Signal Converting Part Done
2022-09-24 Power Management
2022-09-25 改换Buck方案
2022-09-30 MOSFET and Inductors
2022-09-30 Buck layout 60%
2022-10-01 Buck Components
2022-10-04 LVDS routing and layouting misc
2022-10-06 Finished routing
2022-10-14 Changed License to SHL
2022-10-21 created subschem and C project
2023-04-06 cleanup and reconstruct
2023-04-06 assigned footprints
2023-04-07 reconstruct
2023-04-08 file sync
2023-04-08 finish
